# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\BSP\inc;..\Code;..\Core;..\Drivers\CMSIS;..\Drivers\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1F800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ../BSP/src/: BSP_Peripherals.c BSP_UART_3.c BSP_TTLServo.c BSP_BatterySettings.c BSP_Battery.c BSP_UART_1.c BSP_SysTick.c BSP_BitBand_F103.c
  group Code
    ../Code/: AHT20.c Peripherals.c TTLServo_Motion.c TTLServo.c TTLServo_Protocol.c Battery_Settings.c Battery.c Battery_Policy.c IP5310.c main.c
  group Core
    ../Core/: stm32f10x_it.c
  group CMSIS
    ../Drivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group Drivers
    ../Drivers/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
